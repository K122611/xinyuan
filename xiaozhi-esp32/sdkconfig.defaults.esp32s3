## xiaozhi-esp32/sdkconfig.defaults.esp32s3
```kconfig
CONFIG_XIAOZHI_NETWORK_WIFI=y
CONFIG_BOARD_TYPE_WAVESHARE_ESP32_S3_TOUCH_AMOLED_1_8_v2=y
```
